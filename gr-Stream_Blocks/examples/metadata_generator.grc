options:
  parameters:
    generate_options: qt_gui
    id: metadata_generator
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: Stream_Blocks_SL_Matrix_Generator_0
  id: Stream_Blocks_SL_Matrix_Generator
  parameters:
    inVlen: '10'
    stride: '2'
    windowSize: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /home/lahiru/metaData/VECTOR_SINK.out
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '10'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '100'
    type: complex
  states: {}

connections:
- [Stream_Blocks_SL_Matrix_Generator_0, '0', blocks_vector_to_stream_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_vector_0, '0', Stream_Blocks_SL_Matrix_Generator_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_2, '0']

metadata:
  file_format: 1
